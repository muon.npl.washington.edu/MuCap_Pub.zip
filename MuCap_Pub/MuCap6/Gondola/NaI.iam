# Autodesk Inventor assembly: NaI
## iProperties
Created: 2007-10
Part Number: NaI
Document SubType Name: Assembly
Designer: pkammel
Author: pkammel
