# Autodesk Inventor part: NaI_plate
## iProperties
Created: 2007-10
Part Number: NaI_plate
Document SubType Name: Modeling
Designer: pkammel
Author: pkammel
## Feature names
1. Extrusion1
2. Hole4
