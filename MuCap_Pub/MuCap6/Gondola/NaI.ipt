# Autodesk Inventor part: NaI
## iProperties
Created: 2007-10
Part Number: NaI
Document SubType Name: Modeling
Designer: pkammel
Author: pkammel
## Feature names
1. Revolution1
