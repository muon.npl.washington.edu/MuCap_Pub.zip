# Autodesk Inventor assembly: Scints
## iProperties
Created: 2007-02
Part Number: Scints
Document SubType Name: Assembly
Designer: John Blackburn
Author: John Blackburn
