# Autodesk Inventor part: TPC61
## iProperties
Shininess: 64.0
Length Units: 11272
Angle Units: 11279
Time Units: 11290
Mass Units: 11286
Length Display Precision: 3
Angle Display Precision: 2
Compacted: True
Part Number: TPC61
Document SubType Name: Modeling
Created: 2004-08
Designer: Lori
Manufacturer: Standard
Standards Organization: Custom
Density: 0.0
Volumn: 0.0
Area: 0.0
PropertySet Name: Model Information
Control State: 0
Master: False
Checked Out: False
Author: Lori
## Feature names
1. Base1
