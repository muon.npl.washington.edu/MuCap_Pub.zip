# Autodesk Inventor part: wc198
## iProperties
Shininess: 64.0
Length Units: 11272
Angle Units: 11279
Time Units: 11290
Mass Units: 11286
Length Display Precision: 3
Angle Display Precision: 2
Compacted: True
Part Number: wc198
Document SubType Name: Modeling
Created: 2004-08
Designer: John Blackburn
Manufacturer: Standard
Standards Organization: Custom
Material: Phenolic
Density: 0.0
Volumn: 0.0
Area: 0.0
PropertySet Name: Model Information
Control State: 0
Master: False
Checked Out: False
Author: John Blackburn
## Feature names
1. Base1
